Commit message: update to stag launch file

File: robots/droplet.urdf (robot description, URDF)
Before this commit: robot bluerov, 5 links, 4 joints
Joints:
- joint base_link_to_cam_0_optical_frame: origin xyz=0.18 0.0 0.0 rpy=-1.57 0.0 -1.57 -> xyz=0.13335 0.0 0.0 rpy=-1.57 0.0 -1.57
